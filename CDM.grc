options:
  parameters:
    author: luke
    generate_options: qt_gui
    id: CDM_Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    sym_map: '[0, 1]'
    type: bpsk
  states: {}
- name: key_length
  id: variable
  parameters:
    value: '8'
  states: {}
- name: norm_factor
  id: variable
  parameters:
    value: 1/4
  states: {}
- name: psk8
  id: variable_constellation
  parameters:
    precision: '8'
    sym_map: '[0, 1]'
    type: 8psk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/luke/Workspace/GNURadio/Code_Division_Multiplexing/output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/luke/Workspace/GNURadio/Code_Division_Multiplexing/output2.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/luke/Workspace/GNURadio/Code_Division_Multiplexing/output3.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/luke/Workspace/GNURadio/Code_Division_Multiplexing/input.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    file: /home/luke/Workspace/GNURadio/Code_Division_Multiplexing/input3.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_1_1
  id: blocks_file_source
  parameters:
    file: /home/luke/Workspace/GNURadio/Code_Division_Multiplexing/input2.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: key_length
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: key_length
    type: complex
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: key_length
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: norm_factor
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: norm_factor
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: norm_factor
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: key_length
    type: complex
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: key_length
    type: complex
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: key_length
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_2
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0, 0, 0, 0, 0, 0)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1, 0, 1, 0, 1, 0, 1)
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 1, 1, 0, 0, 1, 1)
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Input: {-1, +1}
      Output: {0, 1}
    constellation: psk8
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Input: {-1, +1}
      Output: {0, 1}
    constellation: psk8
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Input: {-1, +1}
      Output: {0, 1}
    constellation: psk8
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    comment: |-
      Input: {0, 1}
      Output: {-1, +1}
    constellation: psk8
  states: {}
- name: digital_constellation_encoder_bc_0_0
  id: digital_constellation_encoder_bc
  parameters:
    comment: |-
      Input: {0, 1}
      Output: {-1, +1}
    constellation: psk8
  states: {}
- name: digital_constellation_encoder_bc_0_1
  id: digital_constellation_encoder_bc
  parameters:
    comment: |-
      Input: {0, 1}
      Output: {-1, +1}
    constellation: psk8
  states: {}
- name: digital_constellation_encoder_bc_1
  id: digital_constellation_encoder_bc
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_encoder_bc_1_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_encoder_bc_1_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: bpsk
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: key
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: key2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: key3
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: TX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: key
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: key
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: key2
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: key3
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: key2
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: key3
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: TX
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', virtual_sink_1, '0']
- [blocks_file_source_1, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_file_source_1_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [blocks_file_source_1_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_integrate_xx_0_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', digital_constellation_decoder_cb_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_multiply_xx_0_0_1, '0', blocks_integrate_xx_0_1, '0']
- [blocks_multiply_xx_0_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_2, '0', blocks_add_xx_0, '2']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_repeat_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_repeat_0_0_0, '0', blocks_multiply_xx_0_2, '0']
- [blocks_throttle_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_throttle_0_0, '0', digital_constellation_encoder_bc_1, '0']
- [blocks_throttle_0_0_0, '0', digital_constellation_encoder_bc_1_0, '0']
- [blocks_throttle_0_0_0_0, '0', digital_constellation_encoder_bc_1_0_0, '0']
- [blocks_throttle_0_1, '0', digital_constellation_encoder_bc_0_0, '0']
- [blocks_throttle_0_2, '0', digital_constellation_encoder_bc_0_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_throttle_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_throttle_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', blocks_throttle_0_2, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_throttle_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', blocks_pack_k_bits_bb_0_0_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_repeat_0_0, '0']
- [digital_constellation_encoder_bc_0_0, '0', blocks_repeat_0, '0']
- [digital_constellation_encoder_bc_0_1, '0', blocks_repeat_0_0_0, '0']
- [digital_constellation_encoder_bc_1, '0', virtual_sink_0, '0']
- [digital_constellation_encoder_bc_1_0, '0', virtual_sink_0_0, '0']
- [digital_constellation_encoder_bc_1_0_0, '0', virtual_sink_0_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0_1, '1']
- [virtual_source_0_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [virtual_source_0_0_1, '0', blocks_multiply_xx_0_0_1, '0']
- [virtual_source_0_1, '0', blocks_multiply_xx_0, '1']
- [virtual_source_0_1_0, '0', blocks_multiply_xx_0_2, '1']
- [virtual_source_1, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_1, '0', blocks_multiply_xx_0_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_0_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
